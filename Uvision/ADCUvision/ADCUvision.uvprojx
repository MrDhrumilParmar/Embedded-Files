# Keil uVision project ADCUvision.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADCUvision +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DAC 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube LL:ADC 1.8.1, Device:STM32Cube LL:Common 1.8.1, Device:STM32Cube LL:PWR 1.8.1, Device:STM32Cube LL:RCC 1.8.1, Device:STM32Cube LL:UTILS 1.8.1, Device:Startup 2.6.3
